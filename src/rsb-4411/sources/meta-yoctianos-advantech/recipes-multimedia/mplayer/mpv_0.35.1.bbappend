PACKAGECONFIG:remove = "gl-x11"
PACKAGECONFIG:append = " egl gles2 x11"
