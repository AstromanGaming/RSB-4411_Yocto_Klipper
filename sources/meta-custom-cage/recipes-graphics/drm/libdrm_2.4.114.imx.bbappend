PV = "2.4.122"
SRC_URI = "https://dri.freedesktop.org/libdrm/libdrm-2.4.122.tar.xz"
SRC_URI[sha256sum] = "d9f5079b777dffca9300ccc56b10a93588cdfbc9dde2fae111940dfb6292f251"
S = "${WORKDIR}/libdrm-2.4.122"

PACKAGECONFIG[vivante] = ""

LICENSE = "CLOSED"
LIC_FILES_CHKSUM = "file://dummy;md5=00000000000000000000000000000000"
