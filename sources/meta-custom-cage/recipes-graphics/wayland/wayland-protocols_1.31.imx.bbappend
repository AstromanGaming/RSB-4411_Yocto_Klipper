SRC_URI = "git://github.com/wayland-mirror/wayland-protocols.git;protocol=https;branch=main"
SRCREV = "08d1c7276d41379acfea353b5c739b72d51827e2"
PV = "1.35"
S = "${WORKDIR}/git"

LICENSE = "CLOSED"
LIC_FILES_CHKSUM = "file://dummy;md5=00000000000000000000000000000000"
