SRC_URI = "git://github.com/wayland-mirror/${BPN}.git;branch=1.23;protocol=https"
SRCREV = "a9fec8dd65977c57f4039ced34327204d9b9d779"
PV = "1.23.1"
S = "${WORKDIR}/git"
